# IAR project dgt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_LPC824; CPU_LPC824M201JHI33
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../../../../middleware/FreeRTOS/Source/portable/IAR/ARM_CM0; ../../../../middleware/FreeRTOS/Source/include; ../../../../middleware/FreeRTOS/Source/CMSIS_RTOS; ../../../../devices/LPC824; ../../../../devices/LPC824/drivers; ../../../../CMSIS/Driver/Include; ../../../../CMSIS/Include; ../../../../boards/lpc824/bsp; ../../../../boards/lpc824/user/serial_uart_hal; ../../../../boards/lpc824/user; ../../../../boards/lpc824/user/tasks; ../../../../boards/lpc824/user/hx711; ../../../../boards/lpc824/user/circle_buffer; ../../../../boards/lpc824/user/utils; ../../../../boards/lpc824/user/nv; ../../../../boards/lpc824/user/serial; ../../../../boards/lpc824/user/debug/cpu; ../../../../boards/lpc824/user/debug/log; ../../../../boards/lpc824/user/debug/log/SEGGER_RTT_V612j/RTT; ../../../../boards/lpc824/user/debug/logSEGGER_RTT_V612j
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../boards/lpc824/user
  OBJCOPY.OOCOutputFile: dgt.bin
  ILINK.IlinkOutputFile: dgt.out
  ILINK.IlinkIcfFile: LPC824_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: startup_LPC824.s
  group bsp/board
    ../../bsp/: board.c clock_config.c pin_mux.c
  group bsp/board/hal_drivers
    ../../../../devices/LPC824/drivers/: fsl_acomp.c fsl_adc.c fsl_clock.c fsl_common.c fsl_dma.c fsl_gpio.c fsl_i2c.c fsl_inputmux.c fsl_pint.c fsl_power.c fsl_reset.c fsl_sctimer.c fsl_spi.c fsl_swm.c fsl_syscon.c fsl_usart.c fsl_wkt.c fsl_wwdt.c
  group middleware/freertos
    ../../../../middleware/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../middleware/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../middleware/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group user
    ../../user/: freertos.c main.c
    ../../../../devices/LPC824/: system_LPC824.c
  group user/circle_buffer
    ../../user/circle_buffer/: circle_buffer.c
  group user/debug/cpu
    ../../user/debug/CPU/: cpu_utils.c
  group user/debug/log
    ../../user/debug/log/: log.c
    ../../user/debug/log/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group user/hx711
    ../../user/hx711/: hx711.c
  group user/nv
    ../../user/nv/: nv.c
  group user/serial
    ../../user/serial/: serial.c
  group user/serial_uart_hal
    ../../user/serial_uart_hal/: nxp_serial_uart_hal_driver.c
  group user/tasks
    ../../user/tasks/: adc_task.c cpu_task.c protocol_task.c scale_task.c
  group user/utils
    ../../user/utils/: utils.c
