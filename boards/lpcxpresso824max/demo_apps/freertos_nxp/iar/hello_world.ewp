# IAR project hello_world.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_LPC824; CPU_LPC824M201JHI33
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/LPC824; ../../..; ..; ../../../../../devices/LPC824/drivers; ../../../../../devices/LPC824/utilities; ../../../../../middleware/FreeRTOS/Source/include; ../../../../../middleware/FreeRTOS/Source/portable/IAR/ARM_CM0; ../../../../../middleware/FreeRTOS/Source/CMSIS_RTOS; ../../../../../../../../git/dbg_lib/log; ../../../../../../../../git/dbg_lib/cpu; ../../../../../../../../git/dbg_lib/log/SEGGER_RTT_V612j/RTT; ../../../../../../../../git/dbg_lib/log/SEGGER_RTT_V612j/Syscalls; ../../../../../../../../git/modbus; ../../../../../../../../git/serial_device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: hello_world.srec
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: LPC824_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC824; CPU_LPC824M201JHI33
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/LPC824; ../../..; ..; ../../../../../devices/LPC824/drivers; ../../../../../devices/LPC824/utilities
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../: pin_mux.c pin_mux.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h freertos.c serial.c
  group cmsis_os
    ../../../../../middleware/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group debug/cpu
    ../../../../../../../../git/dbg_lib/CPU/: cpu_utils.c
  group debug/log
    ../../../../../../../../git/dbg_lib/log/: log.c
    ../../../../../../../../git/dbg_lib/log/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../../../git/dbg_lib/log/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_IAR.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/LPC824/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_swm.c fsl_swm.h fsl_swm_connections.h fsl_syscon.c fsl_syscon.h fsl_syscon_connections.h fsl_usart.c fsl_usart.h
  group freertos
    ../../../../../middleware/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../middleware/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group modbus
    ../../../../../../../../git/modbus/: modbus-rtu.c modbus.c
    ../../../../../../../../git/modbus/portable/: modbus_port.c
  group serial_device
    ../../../../../../../../git/serial_device/: serial_device.c
    ../../../../../../../../git/serial_device/portable/: serial_device_port.c
  group source
    ../: hello_world.c
  group startup
    ../../../../../devices/LPC824/iar/: startup_LPC824.s
    ../../../../../devices/LPC824/: system_LPC824.c system_LPC824.h
  group utilities
    ../../../../../devices/LPC824/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
