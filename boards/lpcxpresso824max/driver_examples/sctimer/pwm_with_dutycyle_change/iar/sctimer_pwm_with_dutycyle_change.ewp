# IAR project sctimer_pwm_with_dutycyle_change.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_LPC824; CPU_LPC824M201JHI33
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/LPC824; ../../../..; ..; ../../../../../../platform/utilities/debug_console; ../../../../../../devices/LPC824/drivers; ../../../../../../devices/LPC824/utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sctimer_pwm_with_dutycyle_change.out
  ILINK.IlinkIcfFile: LPC824_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_LPC824; CPU_LPC824M201JHI33
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: sctimer_update_dutycycle.c
  group board
    ../: pin_mux.c pin_mux.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/LPC824/drivers/: fsl_swm.h fsl_swm.c fsl_common.h fsl_common.c fsl_reset.h fsl_reset.c fsl_clock.h fsl_clock.c fsl_swm_connections.h fsl_gpio.h fsl_gpio.c fsl_syscon.c fsl_syscon.h fsl_syscon_connections.h fsl_usart.h fsl_usart.c fsl_iocon.h fsl_sctimer.h fsl_sctimer.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h
  group startup
    ../../../../../../devices/LPC824/: system_LPC824.c system_LPC824.h
    ../../../../../../devices/LPC824/iar/: startup_LPC824.s
  group utilities
    ../../../../../../devices/LPC824/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
